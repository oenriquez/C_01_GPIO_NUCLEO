# Keil uVision project C_01_GPIO_NUCLEO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: C_01_GPIO_NUCLEO +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1
